# Keil uVision project stc8h.uvproj, settings and files
target stc8h (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc8h +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\devices;.\user;.\system
  group user
    ./user/: main.c
  group devices
    ./devices/: lcd1602.c lcd12864.c I2C.c ISP.c
  group system
    ./system/: clock.c
